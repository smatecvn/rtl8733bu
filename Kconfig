## Kconfig
```kconfig
config RTL8733BU
	tristate "Realtek 8733B USB WiFi"
	depends on USB
	---help---
	  Realtek RTL8733BU chipset driver
	  802.11ac USB wireless network adapter
```
